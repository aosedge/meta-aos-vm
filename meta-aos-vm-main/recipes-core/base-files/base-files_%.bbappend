FILESEXTRAPATHS_append := "${THISDIR}/base-files:"

hostname = "${NODE_ID}"
