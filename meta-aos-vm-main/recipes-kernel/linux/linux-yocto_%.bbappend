FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://main_node.cfg \
"
