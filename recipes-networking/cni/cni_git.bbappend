
RDEPENDS_${PN} += "aos-firewall"
