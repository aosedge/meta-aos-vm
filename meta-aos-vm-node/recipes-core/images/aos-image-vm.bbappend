# AOS packages
IMAGE_INSTALL:append = " \
    aos-iamanager \
    aos-servicemanager \
    aos-updatemanager \
    aos-deprov \
"
