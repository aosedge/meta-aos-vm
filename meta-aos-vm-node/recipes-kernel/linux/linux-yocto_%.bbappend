FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://secondary_node.cfg \
"
