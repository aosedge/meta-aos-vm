# Add a user agent to avoid 403 errors from crates.io when fetching dependencies.
FETCHCMD_wget = "wget --user-agent='Mozilla/5.0 (Windows NT 10.0; Win64; x64)'"
