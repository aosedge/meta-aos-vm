RRECOMMENDS:${PN}:remove = "python3-matplotlib python3-numpy"
