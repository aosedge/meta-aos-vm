PACKAGECONFIG_append = " libarchive static"