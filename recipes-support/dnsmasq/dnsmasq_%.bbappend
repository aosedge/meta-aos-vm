# disable dnsmasq daemon

SYSTEMD_AUTO_ENABLE ?= "disable"